options:
  parameters:
    author: myubu
    generate_options: qt_gui
    id: phase_difference
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_rf
  id: variable
  parameters:
    value: 5859e6
  states: {}
- name: frame_rate
  id: variable
  parameters:
    value: '25'
  states: {}
- name: line_rate
  id: variable
  parameters:
    value: frame_rate*lines_per_frame
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    value: '625'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: rx_select
  id: variable_qtgui_chooser
  parameters:
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: samples_per_line
  id: variable
  parameters:
    value: '512'
  states: {}
- name: video_rate
  id: variable
  parameters:
    value: samples_per_line*line_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '255'
    lo: '0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4000'
    scale: 1/1024
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4000'
    scale: 1/1024
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/3.141592653589793
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 180.0/3.141592653589793
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: rx_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 500e3
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate / video_rate
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_rf
    fftsize: '1024'
    plotfreq: 'False'
    plotwaterfall: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_rf
    fftsize: '1024'
    plotwaterfall: 'False'
    rate: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '180'
    ymin: '-180'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '180'
    ymin: '-180'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '8192'
    srate: samp_rate
    type: float
    update_time: '2'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: center_rf
    center_freq1: center_rf
    dev_addr: '"serial=F5C209"'
    gain0: rf_gain
    gain1: rf_gain
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: A:A A:B
    stream_chans: '[0,1]'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: 12e6
    bw1: 12e6
    center_freq0: center_rf
    center_freq1: center_rf
    gain0: '20'
    nchan: '2'
    rx_agc1: Enabled
    samp_rate: samp_rate
    sd_spec0: A:A A:B
    sync: none
    type: fc32
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '720'
    fps: '0'
    height: '625'
    num_channels: '3'
    type: byte
    width: '512'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_rail_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_0, '0', analog_rail_ff_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_float_to_uchar_0, '0', video_sdl_sink_0, '0']
- [blocks_float_to_uchar_0, '0', video_sdl_sink_0, '1']
- [blocks_float_to_uchar_0, '0', video_sdl_sink_0, '2']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_selector_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [mmse_resampler_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_selector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_0, '1', blocks_selector_0, '1']
- [uhd_usrp_source_0, '1', qtgui_sink_x_1, '0']
- [uhd_usrp_source_1, '0', analog_quadrature_demod_cf_0, '0']
- [uhd_usrp_source_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_1, '0']
- [uhd_usrp_source_1, '0', qtgui_sink_x_2, '0']
- [uhd_usrp_source_1, '1', blocks_multiply_conjugate_cc_0_0, '1']

metadata:
  file_format: 1
